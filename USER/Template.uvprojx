# Keil uVision project Template.uvprojx, settings and files
target STM32F407VGT6_1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4, __FPU_PRESENT=1, __FPU_USED =1, __CC_ARM
  c misc: --C99
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\IIC1;..\HARDWARE\IIC2;..\HARDWARE\USART1;..\HARDWARE\LED_INDICATION;..\HARDWARE\SPI1;..\HARDWARE\SPI2;..\HARDWARE\I2S;..\HARDWARE\BEEP;..\HARDWARE\PGA112;..\HARDWARE\24CXX;..\HARDWARE\TM1620;..\HARDWARE\RTC;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\LSENS;..\HARDWARE\ADC1;..\HARDWARE\ADC3;..\SLEEP_ARITHMETIC\inc;..\MALLOC;..\HARDWARE\IWDG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c arm_cortexM4lf_math.lib
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group README
    ../: readme.txt
  group HARDWARE
    ../HARDWARE/USART1/: usart1.c
    ../HARDWARE/LED_INDICATION/: led_indication.c
    ../HARDWARE/SPI1/: spi1.c
    ../HARDWARE/IIC2/: iic2.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/PGA112/: pga112.c
    ../HARDWARE/ADC3/: adc3.c
    ../HARDWARE/ADC1/: adc1.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/RTC/: rtc.c
    ./: flash.c mic_sample.c dcblock.c snore_detection.c
  group MALLOC
    ../MALLOC/: malloc.c
